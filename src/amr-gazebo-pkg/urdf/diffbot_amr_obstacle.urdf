Commit message: README UPDATED

File: src/amr-gazebo-pkg/urdf/diffbot_amr_obstacle.urdf (robot description, URDF)
Before this commit: robot diffbot_amr, 8 links, 7 joints
Links:
- link chassis: geometry collision box size=.4 .2 .1; collision box size=1.1 .2 .1
